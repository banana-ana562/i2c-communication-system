# Keil uVision project Project.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../src/: startup.s tm4c123gh6pm.h main.c
    ../src/drivers/: wtimer.c Servo.c Servo.h UART0.c UART0.h ButtonLED.c ButtonLED.h wtimer.h MPU6050.c MPU6050.h I2C3.c I2C3.h TCS34727.c TCS34727.h LCD.c LCD.h
software components: CMSIS:CORE 5.6.0
